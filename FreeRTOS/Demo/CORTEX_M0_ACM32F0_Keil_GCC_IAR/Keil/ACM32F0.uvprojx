# Keil uVision project ACM32F0.uvprojx, settings and files
target ACM32F0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ACM32F030R8T7 Aisinochip
  pack: Aisinochip.ACM32F0X0.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ACM32F0 +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/ACM32F0.bin ./Objects/ACM32F0.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;..;..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\..\..\Source\portable\RVDS\ARM_CM0;..\..\..\Source\include;..\..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CoreDriver/Device
    ../Core_Drivers/Device/: Startup_ACM32F0x0.s System_ACM32F0x0.c
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_EFLASH.c HAL_EFlash_EX.lib HAL_UART.c HAL_UART_EX.c HAL_GPIO.c
  group Demo_Source
    ../: main.c
    ../../Common/Minimal/: semtest.c integer.c PollQ.c BlockQ.c
  group RTOS_Source
    ../../../Source/: tasks.c list.c queue.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/portable/RVDS/ARM_CM0/: port.c
