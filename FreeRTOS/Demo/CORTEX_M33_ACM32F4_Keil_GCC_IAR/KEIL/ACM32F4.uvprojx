# Keil uVision project ACM32F4.uvprojx, settings and files
target ACM32F4 (6150000::V6.15::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F4 +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/ACM32F4.bin ./Objects/ACM32F4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..;..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\..\..\Source\portable\GCC\ARM_CM4F;..\..\..\Source\include;..\..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CoreDriver/Device
    ../Core_Drivers/Device/: Startup_ACM32F4.s System_ACM32F4.c System_Accelerate.lib
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_GPIO.c HAL_Uart.c HAL_EFlash.c HAL_EFlash_EX.lib
  group Demo_Source
    ../: main.c
    ../../Common/Minimal/: semtest.c integer.c PollQ.c BlockQ.c
  group RTOS_Source
    ../../../Source/: tasks.c list.c queue.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/portable/GCC/ARM_CM4F/: port.c
