# Keil uVision project ACM32G103.uvprojx, settings and files
target ACM32G103 (6150000::V6.15::ARMCLANG)
  device: ACM32G103RCT6 Aisinochip
  pack: Aisinochip.ACM32G1.1.0.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x50000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ACM32G103 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT
  c include: ..;..\Drivers\CMSIS;..\Drivers\Device;..\Drivers\HAL_Driver\Inc;..\..\..\Source\portable\GCC\ARM_CM4F;..\..\..\Source\include;..\..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/CMSIS
    ../Drivers/Device/Templates/: system_acm32g103.c
    ../Drivers/Device/: system_accelerate.lib
    ./: startup_acm32g103.s
  group Drivers/HAL_Driver
    ../Drivers/HAL_Driver/Src/: hal.c hal_uart.c hal_cortex.c hal_dma.c hal_rcc.c hal_gpio.c hal_exti.c
  group Demo_Source
    ../: main.c acm32g103_it.c
    ../../Common/Minimal/: semtest.c integer.c PollQ.c BlockQ.c
  group RTOS_Source
    ../../../Source/: tasks.c list.c queue.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/portable/GCC/ARM_CM4F/: port.c
